Commit message: Update smr100_description.urdf

File: urdf/smr100_description.urdf (robot description, URDF)
Before this commit: robot smr100_description, 17 links, 16 joints
Joints:
- joint swing_arm_right_joint: type continuous -> revolute
